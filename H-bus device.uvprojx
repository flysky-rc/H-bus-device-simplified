# Keil uVision project H-bus device.uvprojx, settings and files
target hbus debug (6220000::V6.22::.\ARMCLANG6.22)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FTr8B +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: DEBUG SLIP_EN
  c misc: -mno-unaligned-access -Wno-padded -Wno-unsafe-buffer-usage -Wno-unused-command-line-argument
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group Common source
    ./: startup_stm32g070xx.s GPIO.c HB timer.c HB UART.c LED.c Main.c System.c protocol_slip.c
target hbus release (6230000::V6.23::ARMCLANG)
  device: STM32G070CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: as above
  output: FTr8B
  AfterMake: cmd /c "Post FTr8B release.bat"
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=2
  c misc: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
software components: CMSIS:CORE 6.1.0
